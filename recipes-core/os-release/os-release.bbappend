OS_RELEASE_FIELDS_append = " HOME_URL YNOV_PRODUCT"
HOME_URL = "https://www.ynov.com"
YNOV_PRODUCT = "Expansion Board"
